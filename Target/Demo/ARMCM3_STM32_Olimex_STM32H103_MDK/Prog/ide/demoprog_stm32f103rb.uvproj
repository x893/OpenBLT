# Keil uVision project demoprog_stm32f103rb.uvproj, settings and files
target demoprog_stm32f103rb (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: demoprog_stm32f103rb
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_MD USE_STDPERIPH_DRIVER
  c include: ..\..\Prog;..\lib\stdperiphlib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\lib\stdperiphlib\CMSIS\CM3\CoreSupport;..\lib\stdperiphlib;..\lib\stdperiphlib\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x1e000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Prog
    ../../../../Source/ARMCM3_STM32/MDK/: startup_stm32f10x_md.s
    ../: main.c irq.c led.c timer.c
    ../lib/stdperiphlib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group STM32Lib
    ../lib/stdperiphlib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
