# Keil uVision project stm32f103.uvproj, settings and files
target openbtl_stm32f103rb (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: openbtl_stm32f103rb.bin
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_MD NDEBUG
  c include: ..;..\lib\USB_FS_DEVICE\inc;..\..\..\..\Source;..\..\..\..\Source\ARMCM3_STM32;..\lib\fatfs;..\..\..\..\Source\third_party\fatfs\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Boot
    ../: blt_conf.h hooks.c main.c usb_conf.h usb_desc.c usb_desc.h usb_endp.c usb_istr.c usb_istr.h usb_prop.c usb_prop.h usb_pwr.c usb_pwr.h usb_stub.c
  group Boot/lib/USB_FS_DEVICE
    ../lib/USB_FS_DEVICE/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group Source
    ../../../../Source/: assert.c backdoor.c boot.c com.c cop.c xcp.c
  group Source/ARMCM3_STM32
    ../../../../Source/ARMCM3_STM32/: can.c cpu.c flash.c nvm.c timer.c uart.c usb.c
  group Source/ARMCM3_STM32/MDK
    ../../../../Source/ARMCM3_STM32/MDK/: startup_stm32f10x_md.s
