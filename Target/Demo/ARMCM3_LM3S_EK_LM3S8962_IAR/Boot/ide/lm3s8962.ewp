# IAR project lm3s8962.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S6965 TexasInstruments LM3S6965
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; DEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\Source; ..\..\..\..\Source\ARMCM3_LM3S; ..\..\..\..\Source\ARMCM3_LM3S\IAR; ..; ..\lib; ..\lib\inc; ..\lib\driverlib
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: openbtl_ek_lm3s8962.srec
  ILINK.IlinkOutputFile: openbtl_ek_lm3s8962.out
  ILINK.IlinkIcfFile: ..\..\..\..\Source\ARMCM3_LM3S\IAR\memory.x
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group Boot
    ../: blt_conf.h hooks.c main.c
  group Boot/lib/driverlib
    ../lib/driverlib/: canlib.c canlib.h cpulib.c cpulib.h debug.h flashlib.c flashlib.h gpio.c gpio.h interrupt.c interrupt.h sysctl.c sysctl.h uartlib.c uartlib.h
  group Boot/lib/inc
    ../lib/inc/: hw_can.h hw_flash.h hw_gpio.h hw_ints.h hw_memmap.h hw_nvic.h hw_sysctl.h hw_types.h hw_uart.h
  group Source
    ../../../../Source/: assert.c assert.h backdoor.c backdoor.h boot.c boot.h com.c com.h cop.c cop.h plausibility.h xcp.c xcp.h
  group Source/ARMCM3_LM3S
    ../../../../Source/ARMCM3_LM3S/: can.c can.h cpu.c cpu.h flash.c flash.h nvm.c nvm.h timer.c timer.h types.h uart.c uart.h
  group Source/ARMCM3_LM3S/IAR
    ../../../../Source/ARMCM3_LM3S/IAR/: cstart.s vectors.c
