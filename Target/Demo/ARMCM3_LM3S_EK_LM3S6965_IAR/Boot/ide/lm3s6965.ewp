# IAR project lm3s6965.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S6965 TexasInstruments LM3S6965
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; DEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\Source; ..\..\..\..\Source\third_party\fatfs\src; ..\..\..\..\Source\third_party\uip\uip; ..\..\..\..\Source\third_party\uip\apps\hello-world; ..\..\..\..\Source\ARMCM3_LM3S; ..\..\..\..\Source\ARMCM3_LM3S\IAR; ..; ..\lib; ..\lib\inc; ..\lib\driverlib; ..\lib\fatfs; ..\lib\uip
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: openbtl_ek_lm3s6965.srec
  ILINK.IlinkOutputFile: openbtl_ek_lm3s6965.out
  ILINK.IlinkIcfFile: ..\..\..\..\Source\ARMCM3_LM3S\IAR\memory.x
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group Boot
    ../: blt_conf.h hooks.c main.c
  group Boot/lib/driverlib
    ../lib/driverlib/: cpulib.c cpulib.h debug.h ethernet.c ethernet.h flashlib.c flashlib.h gpio.c gpio.h interrupt.c interrupt.h pin_map.h ssi.c ssi.h sysctl.c sysctl.h uartlib.c uartlib.h
  group Boot/lib/fatfs
    ../lib/fatfs/: ffconf.h mmc.c
  group Boot/lib/inc
    ../lib/inc/: hw_ethernet.h hw_flash.h hw_gpio.h hw_ints.h hw_memmap.h hw_nvic.h hw_ssi.h hw_sysctl.h hw_types.h hw_uart.h
  group Boot/lib/uip
    ../lib/uip/: clock-arch.c clock-arch.h netdev.c netdev.h uip-conf.h
  group Source
    ../../../../Source/: assert.c assert.h backdoor.c backdoor.h boot.c boot.h com.c com.h cop.c cop.h file.c file.h net.c net.h plausibility.h xcp.c xcp.h
  group Source/ARMCM3_LM3S
    ../../../../Source/ARMCM3_LM3S/: cpu.c cpu.h flash.c flash.h nvm.c nvm.h timer.c timer.h types.h uart.c uart.h
  group Source/ARMCM3_LM3S/IAR
    ../../../../Source/ARMCM3_LM3S/IAR/: cstart.s vectors.c
  group Source/third_party/fatfs
    ../../../../Source/third_party/fatfs/src/: diskio.h ff.c ff.h integer.h
    ../../../../Source/third_party/fatfs/src/option/: unicode.c
  group Source/third_party/uip
    ../../../../Source/third_party/uip/uip/: clock.h lc-addrlabels.h lc-switch.h lc.h pt.h uip-fw.h uip-neighbor.h uip-split.h uip.c uip.h uip_arch.h uip_arp.c uip_arp.h uip_timer.c uip_timer.h uiplib.c uiplib.h uipopt.h
