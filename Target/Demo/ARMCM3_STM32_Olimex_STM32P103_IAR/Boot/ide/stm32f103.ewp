# IAR project stm32f103.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\..\Source; ..\..\..\..\Source\third_party\fatfs\src; ..\..\..\..\Source\ARMCM3_STM32; ..\..\..\..\Source\ARMCM3_STM32\IAR; ..; ..\lib\fatfs; ..\lib\CMSIS\CM3\CoreSupport; ..\lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\lib\STM32F10x_StdPeriph_Driver\inc; ..\lib\STM32F10x_StdPeriph_Driver
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: openbtl_olimex_stm32p103.srec
  ILINK.IlinkOutputFile: openbtl_olimex_stm32p103.out
  ILINK.IlinkIcfFile: ..\..\..\..\Source\ARMCM3_STM32\IAR\memory.x
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group Boot
    ../: blt_conf.h hooks.c main.c
  group Boot/lib/cmsis
    ../lib/CMSIS/CM3/CoreSupport/: core_cm3.c core_cm3.h
    ../lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Boot/lib/fatfs
    ../lib/fatfs/: ffconf.h mmc.c
  group Boot/lib/stdperiphlib
    ../lib/STM32F10x_StdPeriph_Driver/: stm32f10x_conf.h
    ../lib/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c
    ../lib/STM32F10x_StdPeriph_Driver/inc/: stm32f10x_gpio.h stm32f10x_rcc.h stm32f10x_spi.h stm32f10x_usart.h
  group Source
    ../../../../Source/: assert.c assert.h backdoor.c backdoor.h boot.c boot.h com.c com.h cop.c cop.h file.c file.h plausibility.h xcp.c xcp.h
  group Source/ARMCM3_STM32
    ../../../../Source/ARMCM3_STM32/: can.c can.h cpu.c cpu.h flash.c flash.h nvm.c nvm.h timer.c timer.h types.h uart.c uart.h usb.c usb.h
  group Source/ARMCM3_STM32/IAR
    ../../../../Source/ARMCM3_STM32/IAR/: cstart.s vectors.c
  group Source/third_party/fatfs
    ../../../../Source/third_party/fatfs/src/: diskio.h ff.c ff.h integer.h
    ../../../../Source/third_party/fatfs/src/option/: unicode.c
